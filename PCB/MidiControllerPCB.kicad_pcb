# Repository jcksnvllxr80/MidiController

File README:

This is a midi controller using Raspberry Pi. Written in python. Used to be pedal looper project but removed all the looper / switcher parts and only use midi now.

to take picture with pi can and display on oled screen
$ raspistill -o image.jpg
$ pi@raspberrypi:~ $ python
  Python 2.7.16 (default, Oct 10 2019, 22:02:15)
  [GCC 8.3.0] on linux2
  Type "help", "copyright", "credits" or "license" for more information.
  >>> from PIL import Image
  >>> image = Image.open('image.jpg')
  >>> new_image = image.resize((128, 64))
  >>> new_image.save('new_image.ppm')
$ python /home/pi/Adafruit_Python_SSD1306/examples/image.py

## KiCad design PCB/MidiControllerPCB.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C13, C14: 0.1uf; C_1206_HandSoldering
C6, C7: 0.01uf; C_1206_HandSoldering
J1: OLED_Display; Pin_Header_Straight_1x07_Pitch1.27mm
J2: fan_header; Pin_Header_Straight_1x02_Pitch2.54mm
J3: TRS_Midi_3; NRJ6HM-1-PRE
J4: TRS_Midi_4; NRJ6HM-1-PRE
J7, J8: DIN_5; Midi-Connector
J24: TRS_Midi_1; NRJ6HM-1-PRE
J25: TRS_Midi_2; NRJ6HM-1-PRE
J35: Raspberry_Pi_2_3; Pin_Header_Straight_2x20_Pitch2.54mm
J41: PIC_debug; Pin_Header_Straight_1x06_Pitch2.54mm
R1, R2, R3, R4, R5, R6, R7, R8, R15, R16, R17, R18: 220; R_1206_HandSoldering
R9, R10, R11, R12, R13, R14, R19, R20, R21, R22, R25, R27, R28, R29, R30, R69: 10k; R_1206_HandSoldering
R23, R24, R26: 1k; R_1206_HandSoldering
R68: 470; R_1206_HandSoldering
R73, R74: 4.7k; R_1206_HandSoldering
SW1, SW2, SW3, SW4, SW5: SW_SPST; Pin_Header_Straight_1x02_Pitch2.54mm
SW6: RGB_Rotary_Enc_PB; Pin_Header_Straight_2x04_Pitch2.54mm
U2: MCP23017_ML; QFN-28-1EP_6x6mm_Pitch0.65mm
U5: CD4050BCN; TSSOP-16_4.4x5mm_Pitch0.65mm
U10: PIC18F26K80_IML; QFN-28-1EP_6x6mm_Pitch0.65mm

Connections:
1_MIDI_Pin5: R18.1, U5.2 (G=A)
1_TRS_MIDI_Tip: R1.1, U5.6 (I=C)
2_MIDI_Pin5: R16.1, U5.4 (H=B)
2_TRS_MIDI_Tip: R3.1, U5.10 (J=D)
3_TRS_MIDI_Tip: R5.1, U5.12 (K=E)
4_TRS_MIDI_Tip: R7.1, U5.15 (L=F)
ChipSelectEnable: J1.6, J35.26 ((~SPI_CE1~)_GPIO7)
DataCommand: J1.3, J35.32 (GPIO12)
FootSw1: C1.1, R9.1, U2.17 (GPA0)
FootSw2: C2.1, R11.1, U2.18 (GPA1)
FootSw3: C3.1, R13.1, U2.19 (GPA2)
FootSw4: C4.1, R19.1, U2.25 (GPB0)
FootSw5: C5.1, R21.1, U2.27 (GPB2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C13.1, C14.1, J1.1, J2.2, J3.1 (S), J4.1 (S), J7.2, J8.2, J24.1 (S), J25.1 (S), J35.6 (GND), J35.9 (GND), J35.14 (GND), J35.20 (GND), J35.25 (GND), J35.30 (GND), J35.34 (GND), J35.39 (GND), J41.3, R25.2, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.2, U2.6 (VSS), U2.11 (A0), U2.13 (A2), U2.29 (EP), U5.8 (VSS), U10.5 (Vss), U10.16 (Vss), U10.29 (PAD)
MIDI_Tx: U5.3 (A), U5.5 (B), U5.7 (C), U5.9 (D), U5.11 (E), U5.14 (F), U10.14 (CANTX/TX1/CCP3/RC6)
MOSI: J1.5, J35.19 ((SPI_MOSI)_GPIO10)
unnamed: C14.2, R68.2, R69.1
unnamed: J3.2 (T), R5.2
unnamed: J3.3 (R), R6.2
unnamed: J4.2 (T), R7.2
unnamed: J4.3 (R), R8.2
unnamed: J7.4, R15.1
unnamed: J7.5, R16.2
unnamed: J8.4, R17.1
unnamed: J8.5, R18.2
unnamed: J24.2 (T), R1.2
unnamed: J24.3 (R), R2.2
unnamed: J25.2 (T), R3.2
unnamed: J25.3 (R), R4.2
unnamed: J35.3 ((SDA1)_GPIO2), R74.2, U2.9 (SDA), U10.12 (SDA/SDI/RC4)
unnamed: J35.5 ((SCL1)_GPIO3), R73.2, U2.8 (SCK), U10.11 (SCL/SCK/RC3)
unnamed: J35.7 ((GCLK)_GPIO4), U2.16 (INTA)
unnamed: J35.11 (GPIO17_(GEN0)), U2.15 (INTB)
unnamed: J41.1, R69.2, U10.26 (~MCLR~/RE3)
unnamed: J41.4, U10.25 (PGD/RX2/RB7)
unnamed: J41.5, U10.24 (PGC/TX2/RB6)
unnamed: R9.2, R10.1, SW1.2
unnamed: R11.2, R12.1, SW2.2
unnamed: R13.2, R14.1, SW3.2
unnamed: R19.2, R20.1, SW4.2
unnamed: R21.2, R22.1, SW5.2
unnamed: R23.1, SW6.7
unnamed: R24.1, SW6.5
unnamed: R26.1, SW6.4
unnamed: R27.1, R29.2, SW6.1
unnamed: R28.2, R30.2, SW6.3
Reset: J1.7, J35.22 (GPIO25_(GEN6))
RotEncA: C6.1, J35.16 (GPIO23_(GEN4)), R27.2
RotEncB: C7.1, J35.18 (GPIO24_(GEN5)), R28.1
RotEncBlue: J35.40 (GPIO21), R23.2
RotEncGreen: J35.38 (GPIO20), R24.2
RotEncPushBttn: R25.1, SW6.6, U2.4 (GPB7)
RotEncRed: J35.36 (GPIO16), R26.2
SCLK: J1.4, J35.23 ((SPI_SCLK)_GPIO11)
VCC: C13.2, J2.1, J35.2 (5V), J41.2, R2.1, R4.1, R6.1, R8.1, R10.2, R12.2, R14.2, R15.2, R17.2, R20.2, R22.2, R29.1, R30.1, R68.1, R73.1, R74.1, SW6.8, U2.5 (VDD), U2.12 (A1), U2.14 (~RESET~), U5.1 (VDD), U10.17 (Vdd)
VEE: J1.2, J35.17 (3V3)

Board: 2 copper layers, 127.0 x 88.9 mm, 62 parts (25 on the bottom side), 56 nets.

## Commit log (part)

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2020-04-19 trial
2020-04-19 fix indent
2020-04-20 test
2020-04-20 fix logic error
2020-04-20 really fix it this time
2020-04-20 really fix it again
2020-04-20 fix it
2020-04-20 fix it !!!!!!!!!1111
2020-04-20 changed the yaml config file
2020-04-20 fix it w30462934-567824356-8298704562093-456
2020-04-22 add concept of song displayed add content to the function of each button
2020-04-22 logic error fix
2020-04-22 fix typos
2020-04-23 test print debug thingy
2020-04-23 fix typo
2020-04-23 more fixes
2020-04-23 more tests
2020-04-23 more trying
2020-04-23 trials
2020-04-23 last try for the night
2020-04-23 fix song up and down button
2020-04-23 add oled class
2020-04-24 add notes
2020-04-24 trying something
2020-04-24 put it back
2020-04-24 remove *
2020-04-24 one more
2020-04-24 trying
2020-04-25 replace lcd with oled
2020-04-25 add import
2020-04-25 fix font issue
2020-04-25 fix font and image folder path
2020-04-25 remove comments from interrupt
2020-04-25 change default font
2020-04-25 break up lines differently
2020-04-25 do a little testing
2020-04-25 trials again
2020-04-25 fix indentation crap
2020-04-25 fix missing object thingy
2020-04-25 test font size 8
2020-04-25 trial pb
2020-04-25 trial to fix things back?
2020-04-25 trying to fix broken crap
2020-04-25 un logging the debug stuffs
2020-04-25 fix display not starting right after boot
2020-04-26 turn back into a service
2020-04-26 change servcice name
2020-04-26 add service file
2020-04-26 make some fixes to service file
2020-04-26 run with sudo
2020-04-26 nohup and log quieting
2020-04-26 try something else
2020-04-26 log midi sent
2020-04-26 change it to info
2020-04-26 add image and remove old notes
2020-04-26 remove old comments
2020-04-27 add stats func change default font type
2020-04-27 fix broken stuff
2020-04-27 fix infiinite loop
2020-04-27 fix dum bindent stuff
2020-04-27 try to fix infinite loop again
2020-04-27 try to fix again
2020-04-27 move a set func call
2020-04-27 fix the fix
2020-04-27 make the time ip and stat show longer
2020-05-02 attempt at changing part and song simultaneously
2020-05-02 second try
2020-05-03 typo fix
2020-05-03 fix somehting i missed
2020-05-03 fix something i missed part 2
2020-05-03 tweaks
2020-05-03 get rid of my sample service
2020-05-03 change sudo to root
2020-05-03 fix setlist problem
2020-05-03 fix thing i last tried to fix
2020-05-03 clear song datya needs self to call
2020-05-03 fix another byproduct of changes
2020-05-04 make notes for future ref
2020-05-09 add configs for each pedal still need to sort the yamls out
2020-05-09 work on iridium midi config yaml
2020-05-09 work on timeline midi config yaml a little
2020-05-09 working on all pedal midi config yamls
2020-05-10 more timeline midi additions yaml
2020-05-10 log indices of displayed part
2020-05-10 add log on other display method
2020-05-10 finish all but quartz midi config yaml
2020-05-11 add temp to stats
2020-05-11 try to fix
2020-05-12 ta10
2020-05-14 working on sehlah pedal midi config yaml
2020-05-14 remove a few methods from working
2020-05-14 remove the type parameters
2020-05-14 move some files around and change a few things
2020-05-15 working on dynamic classes for midi functionality
2020-05-16 working toward using yamls to config pedals
2020-05-16 mess up
2020-05-16 change dict key to int
2020-05-16 fix formatting
2020-05-16 remove extraneous verbiage
2020-05-16 change order of init
2020-05-16 fix bigsky yaml
2020-05-16 add set preset for scarlette loce
2020-05-16 edit song yamls to rm superswitcher engage
2020-05-16 add a test log
2020-05-16 trying to fix broken part = none thing
2020-05-16 tryinbg to figure out why brokey
2020-05-17 missed self
2020-05-17 rename functions and invert display
2020-05-17 trail 1
2020-05-17 undo trials
2020-05-19 add todo file
2020-05-19 add to note
2020-05-19 oops
2020-05-19 small fix - extra vars
2020-05-19 another little fix - need numpy package
2020-05-19 timer
2020-05-19 move paranethesis
2020-05-19 bring in copy of looper pcb kicad proj
2020-05-19 progress toward schematic being done
2020-05-20 schematic: nothing todo list: modify notes
2020-05-20 pcb almost done
2020-05-21 modify pcb
2020-05-21 update pcb
2020-05-22 sent off board to be printed
2020-06-07 modify pcb
    1. move the SPI chip enable wire that controls the OLED from rpi CE1 to CE0
    2. swap r68 and r69 as they are in the wrong positions... opps
2020-06-07 zip fab files
2020-06-24 restore previous brightness after part selected
2020-06-24 make the pulse smoother
2020-06-24 try again
2020-06-25 added forgotten self
2020-07-17 add partner function logging
2020-07-18 add 2 btn funcs
2020-07-18 use the func correctly
2020-07-18 add long press function
2020-07-18 another touch up
2020-07-18 little fixy
2020-07-18 missed this
2020-07-18 one more try at a fix
2020-07-18 asdfk;jghadfg
2020-07-18 asdfafgd
2020-07-18 capture all ips
2020-07-18 adfgsdfgh
2020-07-19 working on getting each part to load the settings
2020-07-20 try to add presets on change of song
2020-07-20 typo
2020-07-26 add settings and params
2020-07-26 tweakies
2020-07-26 more trying to get params to function
2020-07-26 more tries
2020-07-26 fixed issue
2020-07-26 fixed another issue
2020-07-26 troubleshooting
2020-07-26 fix yaml off on conversion strange behavior
2020-07-26 fix problem for good?
2020-07-26 stupid fix that wasnt supposed to be there
2020-07-26 cant just use the none trick willy nilly
2020-07-26 same stuff
2020-07-27 try something
2020-07-27 reset that last one
2020-07-27 more of a similar problem ive been having
2020-07-27 another similar booboo
2020-08-08 try to get iridium params set first try
2020-08-08 try morethings for iridium
2020-08-08 trying room size and cab settings
2020-08-08 fix whitespace issue
2020-08-08 add iridium room level remove preset on iridium for main setup
2020-08-08 fgsdfgsdfg
2020-08-08 room level remove
2020-08-08 big changes to menu system. trying to add pedal configuration options
2020-08-09 big changes again
2020-08-09 getting closer to goal
2020-08-09 try something new
2020-08-09 hopeful for a breakthru
2020-08-09 can i get a little further please?
2020-08-09 one mo gin?
2020-08-09 almost there!
2020-08-09 comment BPM menu out
2020-08-09 refactor code
2020-08-09 do a switcharooski put some code where it belongs
2020-08-10 third try, no million bucks :/
2020-08-10 4th try
2020-08-10 try again will def break
2020-08-10 test removing the log printer
2020-08-10 maybe solved
2020-08-10 sdfasedfasdfa
2020-08-10 this should do it!
2020-08-10 hope this works!
2020-08-10 syntax silliness
2020-08-10 here we go!
2020-08-10 try to go further
2020-08-22 wip get pb to activate functions for deepest menu
2020-08-22 same goal as before
2020-08-22 same goal try number 3
2020-08-22 trying to keep the menu from restarting at 0
2020-08-22 fix copy and paste error
2020-08-22 try to get func min max to dispay
2020-08-22 try to fix menu reset elem to 0
2020-08-22 test to see what a certain thing does
2020-08-22 put the test thingy back
2020-08-22 try to add parent for pedal menus
2020-08-22 fix mistake from last commit
2020-08-22 trying to get the display to act the same always
2020-08-22 remove extra : from menu names
2020-08-22 do show parent on None od main menu
2020-08-22 same goal as liast time
2020-08-22 test left justify oled display
2020-08-22 start x 1 pixel in
2020-08-23 fix where i left off self fix another one of those famous copy and paste errors
2020-08-23 add pc and handle each type of opt command try to not set menu items to zero everytime
2020-08-23 add too many self's this time :D
2020-08-23 fix one line if syntax error.. too much java 4 me
2020-08-23 bullet proof test point printer
2020-08-23 fix data position = None prob
2020-08-23 try moving the oled x start pos a little in
2020-08-23 some housekeeping
2020-08-23 left one thing off last commiti
2020-08-23 tiny bit more to the right
2020-08-23 it wasnt movbing at all before lol
2020-08-23 stringify on and off in yml files
2020-08-23 shore up yml
2020-08-23 add amp names in iridium
2020-08-23 iridium changes
2020-08-23 fix ascii char copied from pdf strymon iridium
2020-08-23 - do lots of housekeeping harnessing pycharm's help - add method for make midi configuration changes to the midi pedals
2020-08-23 - fix a legacy text error while renaming on one of the last commits
2020-08-23 - do more housekeeping
2020-08-23 - do more housekeeping again - try to impl midi commands via user pedal interface
2020-08-23 - do more housekeeping (pycharm is great) - attempt to get a Bigsky 'type' know to work with params
2020-08-23 - need the constructor to make a dict that way
2020-08-23 - syntactically sound, logically not sound at the moment - WIP
2020-08-23 - refactor to try again
2020-08-23 - think i cracked this first case
2020-08-23 - maybe now?
2020-08-23 - still trying :/
2020-08-23 - still trying ://
2020-08-23 - still trying :////
2020-08-23 - still trying :///// - house keeping
2020-08-23 - still trying ://////
2020-08-24 - house keeping
2020-08-24 - a little house keeping
2020-08-24 - change to debug logging level
2020-08-24 - fix the setup.py stuff
2020-08-24 - fix the problem that gets me to the next step
2020-08-24 - add an attempt to get params with just a value working.
2020-08-24 attempt same things as last time but this time i think i got it
2020-08-24 i really think i have it this time :)
2020-08-24 decked out Bigsky config with all real names for options
2020-08-24 housekeeping
2020-08-24 - 1 housekeeping item - use a sorted list instead of the randomness a dictionary gives back just by reading its keys, for reading and displaying the midi pedal options with 'dict' in them
2020-08-24 - try to add a progress bar typoe thing with the bigsky swell
2020-08-24 - try to add a progress bar typoe thing with the bigsky params > boost option
2020-08-24 - oops on the last thing
2020-08-24 - a char is causing me grief still
2020-08-24 - a was never causing me grief... it was indentation :(
2020-08-24 - try to fix menu to always have parent-child-grandchild view
2020-08-24 - try to fix menu to always have parent-child-grandchild view part 2
2020-08-24 - try to fix menu to always have parent-child-grandchild view part 3
2020-08-24 - pimp out the timeline and bigsky configs completely
2020-08-25 - one little line between oled text.
2020-08-25 - no line between oled text.
2020-08-25 - configure for multiple delimiters
2020-08-25 - configure for multiple delimiters part try again 1
2020-08-25 - touch up iridium config
2020-08-25 dont mess with params in the main yml file for now as it works already. im just not ready to use it
2020-08-25 - test using other functions in midi controller like engage, toggle bypass, etc
2020-08-25 - test using other functions in midi controller like engage, toggle bypass, etc try again
2020-08-25 - try a different char for filling up space better with pedal configs
2020-08-25 - try a different char for filling up space better with pedal configs - fix a broken thing i broke last time :/
2020-08-26 - attempt at making set preset work from the pedals menu system
2020-08-26 - attempt at making set preset work from the pedals menu system part 2
2020-08-26 - attempt at making set preset work from the pedals menu system part 3
2020-08-26 - one more case handle 'set tempo'
2020-08-26 test somethig that should work
2020-08-26 test somethig that should work again
2020-08-26 cant get scarlette love set preset yet. will conquer tomorrow
2020-08-26 try once more
2020-08-26 got it
2020-08-27 working on final case for pedal configuration from pedal ui
2020-08-27 join IPs by ' - ' instead of "\n"
2020-09-05 modify gitignore
2020-09-06 expose some controller func via http api
2020-09-06 correct vars
2020-09-06 add button lock state menu in global
2020-09-06 change nodes after lock set
2020-09-06 refactor
2020-09-06 try with an int
2020-09-06 make sure the lock is based on current config not a stale one
2020-09-06 fix legacy code
2020-09-08 add api for dpad control from web app
2020-09-08 fix logical error
2020-09-08 fix copy/paste type error
2022-03-05 remove unwanted files from remote
2022-03-05 small changes
2022-03-13 add friendly preset display parameters
